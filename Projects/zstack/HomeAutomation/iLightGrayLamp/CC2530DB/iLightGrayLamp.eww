<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iLightGrayLamp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iLightGrayLamp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>iLightGrayLamp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>iLightGrayLamp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>iLightGrayLamp</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


