<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iLightTemperature.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iLightTemperature</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>iLightTemperature</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>iLightTemperature</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>iLightTemperature</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


