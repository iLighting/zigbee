<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iLightIlluminance.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iLightIlluminance</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>iLightIlluminance</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>iLightIlluminance</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>iLightIlluminance</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


