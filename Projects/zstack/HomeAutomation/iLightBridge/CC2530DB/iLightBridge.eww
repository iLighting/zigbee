<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iLightBridge.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iLightBridge</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>iLightBridge</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>iLightBridge</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>iLightBridge</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


