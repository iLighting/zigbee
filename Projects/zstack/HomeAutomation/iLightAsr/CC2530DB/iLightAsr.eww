<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iLightAsr.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iLightAsr</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>iLightAsr</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>iLightAsr</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>iLightAsr</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


