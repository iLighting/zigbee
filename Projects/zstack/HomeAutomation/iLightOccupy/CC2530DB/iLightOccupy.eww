<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iLightOccupy.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iLightOccupy</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>iLightOccupy</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>iLightOccupy</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>iLightOccupy</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


