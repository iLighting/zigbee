<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iLightLamp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iLightLamp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>iLightLamp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>iLightLamp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>iLightLamp</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


